Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.1]
File name: Technogym Reform_diamond black_3D.ifc
Time: 2025-04-15T08:55:19
Written by: pCon.planner

# IfcBuilding
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m

# IfcBuildingStorey
Elevation: 0 m
