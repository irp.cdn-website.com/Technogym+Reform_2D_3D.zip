Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.1]
File name: Technogym Reform_sandstone_3D.ifc
Time: 2025-04-15T08:54:30
Written by: pCon.planner

# IfcBuilding
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m

# IfcBuildingStorey
Elevation: 0 m
